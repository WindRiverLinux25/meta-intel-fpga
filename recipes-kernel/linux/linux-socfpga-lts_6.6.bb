LINUX_VERSION = "6.6.51"
LINUX_VERSION_SUFFIX = "-lts"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCREV = "0cf70af8bbb0ab464ceaedd19014c206cea45c28"

include linux-socfpga.inc
