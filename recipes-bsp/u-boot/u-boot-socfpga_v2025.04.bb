require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2025.04"

SRCREV = "bcc038aed6b2b5a81087fedfc9f36b74894c735e"
