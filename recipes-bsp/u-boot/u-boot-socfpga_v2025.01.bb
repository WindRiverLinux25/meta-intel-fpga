require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2025.01"

SRCREV = "0abd2517c4942ab74f94e116a5f04393b7ec8247"
