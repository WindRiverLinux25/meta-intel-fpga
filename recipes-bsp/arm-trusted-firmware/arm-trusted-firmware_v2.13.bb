require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=6ed7bace7b0bc63021c6eba7b524039e"

ATF_VERSION = "v2.13.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "311f620ae6f569a2438299cdd764520b72478add"
