require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b5fbfdeb6855162dded31fadcd5d4dc5"

ATF_VERSION = "v2.11.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "96c4f82b90a94caffd1e861f2a77f368c011ef72"
