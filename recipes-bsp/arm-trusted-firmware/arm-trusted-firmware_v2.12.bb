require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=83b7626b8c7a37263c6a58af8d19bee1"

ATF_VERSION = "v2.12.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "5ec7b414bd89b8405870cdd0663e79825d698bce"
